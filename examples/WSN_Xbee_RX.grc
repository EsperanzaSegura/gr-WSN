<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>WSN_Xbee_Chronos</value></param>
<param><key>title</key><value>WSN Xbee &amp; Chronos</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>v_srcieee</value></param>
<param><key>value</key><value>[0x12,0x34,0x56,0x40,0x00,0xA2,0x13,0x00]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>channel</value></param>
<param><key>value</key><value>11 if TAB==0 else 22</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>v_panid</value></param>
<param><key>value</key><value>[0xFD,0x6C] if TAB==0 else [0x87,0x49]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>v_srcadd</value></param>
<param><key>value</key><value>[0x12,0x34]</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>frec</value></param>
<param><key>label</key><value>Fc</value></param>
<param><key>value</key><value>2405e6 +5e6*(channel-11)</value></param>
<param><key>min</key><value>2405e6</value></param>
<param><key>max</key><value>2480e6</value></param>
<param><key>num_steps</key><value>15</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(5,1,2,1)</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>TAB</value></param>
<param><key>label</key><value>Modulo Xbee</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>["Xbee s2", "Xbee PRO"]</value></param>
<param><key>type</key><value>drop_down</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>(1,1,2,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain_rx</value></param>
<param><key>label</key><value>Ganancia RX</value></param>
<param><key>value</key><value>37</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>70</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(3,3,2,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain_tx</value></param>
<param><key>label</key><value>Ganancia Tx</value></param>
<param><key>value</key><value>45</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>80</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(3,5,2,1)</value></param>
</block>
<block>
<key>variable_text_box</key>
<param><key>id</key><value>msj</value></param>
<param><key>label</key><value>Mensaje</value></param>
<param><key>value</key><value>"1  "</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(5,3,3,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>t_msj</value></param>
<param><key>label</key><value>Tiempo Msj [ms]</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>min</key><value>200</value></param>
<param><key>max</key><value>2000</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(5,7,2,1)</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>squelch_lv</value></param>
<param><key>label</key><value>Squelch [db]</value></param>
<param><key>value</key><value>-50</value></param>
<param><key>min</key><value>-90</value></param>
<param><key>max</key><value>-30</value></param>
<param><key>num_steps</key><value>40</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>(3,1,2,1)</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>labe_text</value></param>
<param><key>label</key><value>PanId</value></param>
<param><key>value</key><value>[hex(v_panid[i]) for i in range(2)]</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(1,3,2,1)</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>labe_text_0</value></param>
<param><key>label</key><value>Samp Rate</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>converver</key><value>str_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>(1,5,2,1)</value></param>
</block>
<block>
<key>WSN_rx_app_xbee</key>
<param><key>id</key><value>WSN_rx_app_xbee_0</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
<param><key>host</key><value></value></param>
<param><key>port</key><value>10001</value></param>
<param><key>mtu</key><value>200</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
</block>
<block>
<key>WSN_rx_mac_802_15_4</key>
<param><key>id</key><value>WSN_rx_mac_802_15_4_0</value></param>
<param><key>SrcAddR</key><value>v_srcadd</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>"type=b200"</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:A</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>frec</value></param>
<param><key>gain0</key><value>gain_rx</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>samp_rate</value></param>
<param><key>comment</key><value>Power USB3.0
Antena RF: A RX2</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>wxgui_fftsink2_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Espectro</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>frec</value></param>
<param><key>y_per_div</key><value>5</value></param>
<param><key>y_divs</key><value>15</value></param>
<param><key>ref_level</key><value>-30</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>20</value></param>
<param><key>peak_hold</key><value>True</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.3</value></param>
<param><key>win</key><value>None</value></param>
<param><key>freqvar</key><value>None</value></param>
</block>
<block>
<key>WSN_rx_nwk_zigbee</key>
<param><key>id</key><value>WSN_rx_nwk_zigbee_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>rx_phy_oqpsk</key>
<param><key>id</key><value>rx_phy_oqpsk_0</value></param>
<param><key>squ</key><value>squelch_lv</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>WSN_rx_mac_802_15_4_0</source_block_id><sink_block_id>WSN_rx_nwk_zigbee_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>rx_phy_oqpsk_0</source_block_id><sink_block_id>WSN_rx_mac_802_15_4_0</sink_block_id><source_key>to_Mac</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>WSN_rx_app_xbee_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>WSN_rx_nwk_zigbee_0</source_block_id><sink_block_id>WSN_rx_app_xbee_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>rx_phy_oqpsk_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0_0</source_block_id><sink_block_id>wxgui_fftsink2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rx_phy_oqpsk_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>to_Mac</source_key><sink_key>print_pdu</sink_key></connection>
</flow_graph>
